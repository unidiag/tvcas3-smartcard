# Keil uVision project THC20F17BD_V40_DEMO_RC_01.uvproj, settings and files
target THC20F17BD_V40_DEMO (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: THC20F17BD_V40_DEMO +hex
  c flags: Optimize=9
  c misc: NOINTVECTOR
  group 8051SYS
    ./8051SYS/: STARTUP.A51 Main.c
  group ISO7816
    ./ISO7816/: ISO7816_API.c ISO7816_Interrupt.c ISO7816_Main.c
